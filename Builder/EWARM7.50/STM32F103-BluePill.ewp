# IAR project STM32F103-BluePill.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\CubeF1Drivers; ..\..\CubeF1Drivers\CMSIS\Include; ..\..\CubeF1Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\CubeF1Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\OS; ..\..\OS\FreeRTOS\include; ..\..\OS\FreeRTOS\portable\ARM_CM3; ..\..\APL\Driver; ..\..\APL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\OS; ..\..\APL
  OBJCOPY.OOCOutputFile: STM32F103-BluePill.srec
  ILINK.IlinkOutputFile: STM32F103-BluePill.out
  ILINK.IlinkIcfFile: ..\..\CubeF1Drivers\stm32f103x8_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\CubeF1Drivers\CMSIS\Lib\ARM\arm_cortexM3l_math.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APL
    ../../APL/: shell.c
  group APL/Driver
    ../../APL/Driver/: BSP_LED.c ExtLED.c ExtSW.c TIMER.c UART.c
  group Boot
    ../../Boot/: main.c
  group CubeF1Drivers
    ../../CubeF1Drivers/: startup_stm32f103xb.s stm32f1xx_it.c system_stm32f1xx.c
  group CubeF1Drivers/STM32F1xx_HAL_Driver/Src
    ../../CubeF1Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_tim.c
  group OS
    ../../OS/: FreeRTOSConfig.h hook.c
  group OS/FreeRTOS
    ../../OS/FreeRTOS/: list.c queue.c tasks.c timers.c
  group OS/FreeRTOS/portable/ARM_CM3
    ../../OS/FreeRTOS/portable/ARM_CM3/: port.c portasm.s
  group OS/FreeRTOS/portable/MemMang
    ../../OS/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c
